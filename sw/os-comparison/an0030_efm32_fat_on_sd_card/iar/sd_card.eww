<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sd_card_G890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card_G290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
