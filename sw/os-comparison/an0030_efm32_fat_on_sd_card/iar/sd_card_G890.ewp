# IAR project sd_card_G890.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32G\Include; ..\..\..\emlib\inc; ..\..\..\kits\common\bsp; ..\..\..\kits\common\drivers; ..\..\..\reptile\fatfs\inc; ..\..\..\kits\EFM32_Gxxx_DK\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_card_G890.bin
  ILINK.IlinkOutputFile: sd_card_G890.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group BSP
    ../../../kits/common/bsp/: bsp_dk_3200.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group FatFS
    ../../../reptile/fatfs/src/: diskio.c ff.c
    ../../../kits/common/drivers/: microsd.c
  group Source
    ../: main.c
