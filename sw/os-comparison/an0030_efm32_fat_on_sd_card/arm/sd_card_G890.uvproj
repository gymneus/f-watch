# Keil uVision project sd_card_G890.uvproj, settings and files
target sd_card_G890 (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: sd_card_G890
  AfterMake: fromelf.exe --bin --output obj\sd_card_G890.bin obj\sd_card_G890.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\EnergyMicro\EFM32G\Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\reptile\fatfs\inc;..\..\..\kits\EFM32_Gxxx_DK\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group BSP
    ../../../kits/common/bsp/: bsp_dk_3200.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group FatFS
    ../../../reptile/fatfs/src/: diskio.c ff.c
    ../../../kits/common/drivers/: microsd.c
  group Source
    ../: main.c
